<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\10_Nucleo_H743ZIT_RTOS_Test.ewp</path>
  </project>
  <batchBuild />
</workspace>
